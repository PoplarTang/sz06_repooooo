# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Lib;.\User;.\Driver;.\App
  group App
    ./App/: App.h App_Bluetooth.c App_Ultrasonic.c App_Tracker.c App_Battery.c
  group Driver
    ./Driver/: Light.c Key.c Battery.c Ultrasonic.c Ultrasonic.h Motors.h Motors.c Tracker.c Tracker.h Buzzer.c
  group User
    ./User/: main.c
  group Lib
    ./Lib/: UART.c UART_Isr.c Delay.c GPIO.c NVIC.c ADC.c ADC_Isr.c STC8H_PWM.c
  group OS
    ./OS/: Conf_tny.A51 RTX51TNY.LIB
